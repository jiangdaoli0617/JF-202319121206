# Keil uVision project LabManager.uvprojx, settings and files
target LabManager (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: LabManager +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Core;..\bsp;..\middle;..\protocol;..\app;..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ../: main.c
    ../Core/: stm32f10x_it.c delay.c
    ../Libraries/CMSIS/: system_stm32f10x.c startup_stm32f10x_md.s
  group BSP
    ../bsp/: bsp_gpio.c bsp_spi.c bsp_i2c.c bsp_usart.c bsp_rc522.c bsp_ds3231.c bsp_at24c256.c bsp_oled.c bsp_esp8266.c
  group Middle
    ../middle/: drv_rfid.c drv_rtc.c drv_storage.c drv_display.c drv_input.c drv_indicator.c drv_net.c
  group Protocol
    ../protocol/: proto_crc.c proto_tlv.c proto_frame.c
  group App
    ../app/: app_config.c app_auth.c app_inventory.c app_log.c app_fsm.c app_ui.c
  group StdPeriph
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_i2c.c stm32f10x_usart.c
